KV = "4.11.0"
SRCDATE = "20170501"
MODNAMES = "brcmstb-${MACHINE} ci ftm4862 fts260 sp988x"

require os-dvb-modules.inc

COMPATIBLE_MACHINE = "osminiplus"

SRC_URI[md5sum] = "de4c7f7e7e25aa9f617c8956d9c04dd7"
SRC_URI[sha256sum] = "2235873317b11fac2f361fa3e557d649dbe0bc2c24c643cb2324fab68ba6fe71"
