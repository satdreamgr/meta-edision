KV = "4.11.0"
SRCDATE = "20170501"
MODNAMES = "brcmstb-${MACHINE} ci ftm4862 fts260 sp988x"

require os-dvb-modules.inc

COMPATIBLE_MACHINE = "osmini"

SRC_URI[md5sum] = "1f0a2b932f69f3dfdde7657b09399f17"
SRC_URI[sha256sum] = "fbae47b803496e3818dbaeead45364f72d4341b980ee638028476e3c732aff76"
