KV = "4.19.0"
SRCDATE = "20181101"
MODNAMES = "brcmstb-${MACHINE} ci avl6261 avl6862 si2183"

require os-dvb-modules.inc

COMPATIBLE_MACHINE = "osmio4k"

SRC_URI[md5sum] = "f795f5dbec01f859f206c702ae993741"
SRC_URI[sha256sum] = "7f362c3ec2c938f58aa0fc4c3764dd2512e5bfc85dee8ba20d51ebe780a82991"
